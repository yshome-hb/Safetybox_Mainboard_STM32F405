# Keil uVision project Safetybox_Mainboard.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: safetybox_mainboard +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\input_output;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\lcd;..\FONTS;..\HARDWARE\fpc;..\SYSTEM;..\TASKS;..\HARDWARE\veinfinger;..\MENU;..\SYSTEM\spi;..\SYSTEM\gpio;..\SYSTEM\stmflash;..\HARDWARE\device_info;..\SYSTEM\timer;..\CJSON;..\HARDWARE\sipeed_mf1;..\SYSTEM\rtc;..\SYSTEM\iic;..\HARDWARE\sht2x;..\SYSTEM\adc;..\SYSTEM\rtc;..\HARDWARE\esp8266_at;..\HARDWARE\bc35_at;..\SYSTEM\wakeup;..\SYSTEM\exti
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/fpc/: fpc1020a.c
    ../HARDWARE/veinfinger/: veinfinger.c
    ../HARDWARE/lcd/: lcd192x64.c
    ../HARDWARE/device_info/: device_info.c
    ../HARDWARE/sipeed_MF1/: sipeed_mf1.c
    ../HARDWARE/input_output/: input_output.c
    ../HARDWARE/sht2x/: sht2x.c
    ../HARDWARE/esp8266_at/: esp8266_at.c
    ../HARDWARE/bc35_at/: bc35_at.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: stm32f4xx_it.c system_stm32f4xx.c
    ../SYSTEM/spi/: spi_slave.c
    ../SYSTEM/stmflash/: stmflash.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/gpio/: gpio.c
    ../SYSTEM/rtc/: rtc.c
    ../SYSTEM/iic/: hw_iic.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/wakeup/: wakeup.c
    ../SYSTEM/exti/: exti.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_i2c.c stm32f4xx_adc.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group TASKS
    ../TASKS/: fpc_task.c activity_task.c identify_task.c vfinger_task.c face_task.c io_task.c rtc_task.c wifi_task.c nbiot_task.c
  group MENU
    ../MENU/: main_menu.c unlock_menu.c manage_menu.c admin_menu.c lockmode_menu.c common_menu.c useradd_menu.c userdel_menu.c fpcadd_menu.c veinadd_menu.c faceadd_menu.c warn_menu.c systemconfig_menu.c wifi_menu.c nbiot_menu.c systeminfo_menu.c lock_menu.c datetime_menu.c
  group FONTS
    ../FONTS/: GB2312-HZK16.c ascii.c bmp.c
  group CJSON
    ../CJSON/: cJSON.c
